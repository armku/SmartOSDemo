# Keil uVision project SmartOSF1x0.uvprojx, settings and files
target SmartOSF1_Debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SmartOSF1_Debug
  c flags: Optim=1 OneElfS=1
  c define: STM32F1,DEBUG,USE_FULL_ASSERT
  c misc: --cpp11
  c include: ..\SmartOS;..\SmartOS\Core;..\SmartOS\Device;..\SmartOS\Kernel
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.cpp
    ../SmartOS/: SmartOS_F1x0D.lib SmartOS_M3D.lib
    ../Lib/: GD32F1x0D.lib
target SmartOSF1_RTM (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: as above
  output: SmartOSF1_RTM
  AfterMake: XScript.exe Build.cs /NoLogo /NoTime /NoStop /Hide
  c flags: Optim=4 OneElfS=1
  c define: STM32F1
  c misc: --cpp11
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
